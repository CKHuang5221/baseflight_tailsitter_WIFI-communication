# Keil uVision project baseflight.uvprojx, settings and files
target STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flapping wing wifi_old +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,NAZE
  c misc: --c99 --gnu
  c include: lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: cli.c config.c imu.c main.c mixer.c mw.c sensors.c serial.c board.h mw.h spektrum.c buzzer.c utils.c sbus.c sumd.c rxmsp.c blackbox.c gps.c fw_nav.c wifi.c controller.c
  group Drivers
    ./src/: drv_adc.c drv_adxl345.c drv_bmp085.c drv_hmc5883l.c drv_i2c.c drv_mpu3050.c drv_pwm.c drv_system.c drv_uart.c drv_ledring.c drv_mpu6050.c drv_mma845x.c drv_hcsr04.c drv_i2c_soft.c drv_l3g4200d.c drv_ms5611.c drv_gpio.c drv_spi.c drv_timer.c drv_softserial.c drv_bma280.c drv_serial.c drv_mpu6500.c drv_ak8975.c
  group System
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
    ./src/baseflight_startups/: startup_stm32f10x_md.s
    ./src/: printf.c
target STM32-Release (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: baseflight +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,NAZE
  c misc: --c99 --gnu
  c include: CoOS\portable;CoOS\kernel;lib\CMSIS\CM3\CoreSupport;lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32-CJMCU (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: baseflight +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,CJMCU
  c misc: --c99 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0
